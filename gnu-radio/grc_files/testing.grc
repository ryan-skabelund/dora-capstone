options:
  parameters:
    author: ryan
    generate_options: qt_gui
    id: default
    output_language: python
    title: GNU Radio OpenLST
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '7415.77'
  states: {}
- name: offset
  id: variable
  parameters:
    value: 1e5
  states: {}
- name: resamp_rate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: samp_rate/bit_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ryan/Desktop/telemetry
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ryan/Desktop/dora_heartbeat_jan.iq
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-offset'
    sample_rate: samp_rate
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {state: bypassed}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: resamp_rate
    sensitivity: '1.0'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '4'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '4'
    ted_gain: '1.0'
    ted_type: digital.TED_MENGALI_AND_DANDREA_GMSK
    type: cc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 50e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: samp_per_sym/resamp_rate
    type: complex
  states: {}
- name: openlst_openlst_demod_0
  id: openlst_openlst_demod
  parameters:
    fec: 'True'
    flags: '0'
    flags_mask: '128'
    preamble_bytes: '4'
    preamble_quality: '30'
    sync_byte0: '145'
    sync_byte1: '211'
    sync_words: '2'
    whitening: 'True'
  states: {}
- name: openlst_raw_file_sink_0
  id: openlst_raw_file_sink
  parameters:
    file_path: output_file.txt
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_file_source_0, '0', qtgui_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [digital_gfsk_demod_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_gfsk_demod_0, '0', openlst_openlst_demod_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_gfsk_demod_0, '0']
- [low_pass_filter_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [openlst_openlst_demod_0, message, openlst_raw_file_sink_0, message]

metadata:
  file_format: 1
